Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Costanera+clip+emb38.IFC
Time: 2022-09-05T20:36:03
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Clip emballetado 38 abierto_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Clip emballetado 38 cerrado_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Panel emballetado 38-1_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Panel emballetado 38-2_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Panel madera_910
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Tornillo zinc autoperforante corto_Default (18)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
