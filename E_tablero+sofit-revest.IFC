Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_tablero+sofit-revest.IFC
Time: 2022-09-05T20:42:32
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Panel madera_A48
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Sofit panel_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Tornillo zinc autoperforante largo_75 (6)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
