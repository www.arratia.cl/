Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_concreto+mullion+calamina vert-revestimiento.IFC
Time: 2022-09-05T20:25:30
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Escuadra mullion_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Extruir-Lámina1[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pared concreto_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Concreto

# IfcBuildingElementProxy: Perfil mullion_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tornillo zinc autoperforante corto_Default (33)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
18 x Tornillo zinc autoperforante corto_Default | 0
15 x Tornillo zinc autoperforante corto_Default | Acero galvanizado
