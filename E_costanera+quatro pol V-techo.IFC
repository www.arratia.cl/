Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_costanera+quatro pol V-techo.IFC
Time: 2022-09-05T20:27:04
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Extruir-Lámina1[1] (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[2] (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Saliente-Extruir1 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Tornillo zinc autoperforante largo_75 (9)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
