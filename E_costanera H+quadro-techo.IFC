Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_costanera H+quatro-techo.IFC
Time: 2022-09-06T20:35:16
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Panel QUATRO techo_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Panel madera_910
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Tornillo corto autoperforante lenteja_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
