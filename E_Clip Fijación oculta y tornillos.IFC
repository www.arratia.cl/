Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_Clip Fijación oculta y tornillos.IFC
Time: 2022-09-05T20:30:58
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Clip de fijación FO
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Tornillo zinc autoperforante cabeza plana_75 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
