Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_concreto+mullion+tinglado-revest.IFC
Time: 2022-09-06T20:46:28
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Escuadra mullion_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: GANCHO tinglado_Default (12)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Panel tinglado_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Pared concreto_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Concreto

# IfcBuildingElementProxy: Perfil mullion_larga (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tornillo corto autoperforante lenteja_Default (12)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado

# IfcBuildingElementProxy: Tornillo zinc autoperforante corto_Default (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
