Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_Costanera+colonial horiz- revestimiento.IFC
Time: 2022-09-05T20:26:20
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Extruir-Lámina1[10] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[11] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[12] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[13] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[14] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[15] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[16] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[17] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[18] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[19] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[1] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[20] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[21] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[22] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[23] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[24] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[25] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[26] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[27] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[28] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[29] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[3] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[4] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[5] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[6] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[7] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[8] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[9] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Panel madera_calamina
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Tornillo zinc autoperforante corto_Default (18)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
