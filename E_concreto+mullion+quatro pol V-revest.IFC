Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_concreto+mullion+quatro pol V-revest.IFC
Time: 2022-09-05T20:24:31
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Escuadra mullion_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Extruir-Lámina1[1] (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Extruir-Lámina1[2] (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pared concreto_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Concreto

# IfcBuildingElementProxy: Perfil mullion_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Saliente-Extruir1 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Tornillo zinc autoperforante corto_Default (18)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tornillo zinc autoperforante largo_75 (9)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
