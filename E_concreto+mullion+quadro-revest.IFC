Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_concreto+mullion+quatro-revest.IFC
Time: 2022-09-06T20:33:48
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Escuadra mullion_Default (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Panel QUATRO rect_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Pared concreto_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Concreto

# IfcBuildingElementProxy: Perfil mullion_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tornillo corto autoperforante lenteja_Default (9)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado

# IfcBuildingElementProxy: Tornillo zinc autoperforante corto_Default (18)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
