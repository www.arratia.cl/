Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_tablero+calamina-revest.IFC
Time: 2022-09-05T21:35:59
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Calamina M.onduladada_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Panel madera_calamina
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Tornillo corto autoperforante lenteja_Default (9)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
