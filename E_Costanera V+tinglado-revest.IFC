Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: E_Costanera V+tinglado-revest.IFC
Time: 2022-09-06T20:47:41
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: GANCHO tinglado_Default (10)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Panel tinglado_larga (6)
In: Default Storey
PredefinedType: ELEMENT; Material: Aleación de zinc AC41A fundida

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Perfiles nch CANAL 50X30X4(1)[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Tornillo corto autoperforante lenteja_Default (10)
In: Default Storey
PredefinedType: ELEMENT; Material: Acero galvanizado
